<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>rpp0_lorabee_usrp</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bw</value></param>
<param><key>value</key><value>500000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>capture_freq</value></param>
<param><key>value</key><value>868.1e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decimation</value></param>
<param><key>comment</key><value>The decimation determines the oversampling rate.
A sample rate of 1e6 and decimation of 1 equals
8 times oversampling, a decimation of 2 is 4 times
oversampling, and so on. Set higher decimation
for better performance, but worse accuracy.</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>downlink</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>noise_pow</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>1000</value></param>
<param><key>label</key><value>rx_gain</value></param>
<param><key>max</key><value>1400</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sf</value></param>
<param><key>value</key><value>7</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>target_freq</value></param>
<param><key>value</key><value>target_freq_sx1272</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>target_freq_rn2483</value></param>
<param><key>value</key><value>868.08e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>target_freq_sx1272</value></param>
<param><key>value</key><value>868.1e6</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0</value></param>
<param><key>gain</key><value>1</value></param>
</block>
<block>
<key>blocks_sub_xx</key>
<param><key>id</key><value>blocks_sub_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>digital_clock_recovery_mm_xx</key>
<param><key>id</key><value>digital_clock_recovery_mm_xx_0</value></param>
<param><key>gain_mu</key><value>0.03</value></param>
<param><key>gain_omega</key><value>0.000225</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_relative_limit</key><value>0.0002</value></param>
<param><key>omega</key><value>decimation</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>lobee_quad_to_byte_fb</key>
<param><key>id</key><value>lobee_quad_to_byte_fb_0</value></param>
</block>
<block>
<key>lora_lobee_receiver</key>
<param><key>id</key><value>lora_lobee_receiver_0</value></param>
<param><key>bandwidth</key><value>bw</value></param>
<param><key>crc</key><value>True</value></param>
<param><key>center_freq</key><value>target_freq</value></param>
<param><key>cr</key><value>4</value></param>
<param><key>disable_drift_correction</key><value>False</value></param>
<param><key>implicit</key><value>False</value></param>
<param><key>packet_len</key><value>7</value></param>
<param><key>path</key><value>"/home/wangzhe/sjtu/USRP/RPP0/gr-lobee-encoder/"</value></param>
<param><key>reduced_rate</key><value>False</value></param>
<param><key>samp_rate</key><value>samp_rate/decimation</value></param>
<param><key>sf</key><value>sf</value></param>
<param><key>sync_shift</key><value>4</value></param>
</block>
<block>
<key>lora_lora_receiver</key>
<param><key>id</key><value>lora_lora_receiver_0</value></param>
<param><key>bandwidth</key><value>bw</value></param>
<param><key>crc</key><value>True</value></param>
<param><key>center_freq</key><value>target_freq</value></param>
<param><key>channel_list</key><value>[target_freq]</value></param>
<param><key>cr</key><value>4</value></param>
<param><key>conj</key><value>downlink</value></param>
<param><key>decimation</key><value>decimation</value></param>
<param><key>disable_channelization</key><value>True</value></param>
<param><key>disable_drift_correction</key><value>False</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>implicit</key><value>False</value></param>
<param><key>path</key><value></value></param>
<param><key>reduced_rate</key><value>False</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sf</key><value>sf</value></param>
</block>
<block>
<key>lora_message_socket_sink</key>
<param><key>id</key><value>lora_message_socket_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>ip</key><value>127.0.0.1</value></param>
<param><key>layer</key><value>0</value></param>
<param><key>port</key><value>40868</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_0</value></param>
<param><key>alpha</key><value>0.00016</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>target_freq</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>rx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>"addr=192.168.10.6"</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_1</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>target_freq</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>single_pole_iir_filter_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_0</source_block_id><sink_block_id>digital_clock_recovery_mm_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>lobee_quad_to_byte_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lobee_quad_to_byte_fb_0</source_block_id><sink_block_id>lora_lobee_receiver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_lora_receiver_0</source_block_id><sink_block_id>lora_message_socket_sink_0</sink_block_id><source_key>frames</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>lora_lora_receiver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>wxgui_fftsink2_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
